# Keil uVision project Supercapacitor.uvprojx, settings and files
target Supercapacitor (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F334C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.1
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Supercapacitor
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F334x8
  c include: ../Core/Inc;             ../Drivers/STM32F3xx_HAL_Driver/Inc;             ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;             ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;             ../Drivers/CMSIS/Include;             ..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c hrtim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Application/USER
    ../USER/: user_ad.c user_hrtim.c user_pwm.c
software components: CMSIS:CORE 4.3.0
